# Keil uVision project dummy.uvprojx, settings and files
target Tests (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT, STM32F10X_MD
  c misc: --exceptions
  c include: .\src\cmsis;.\src;..\;.\src\mcu_support_package\inc
  asm define: Stack_Size=0x2000, Heap_Size=0x2000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group main
    ./src/Main/: main.cpp
    ./src/main/: basic_math_test.cpp simple_test.cpp
  group umba_cpp_test
    ../: umba_cpp_tests.cpp umba_cpp_tests.h
    ./src/: umba_cpp_test_config.h
  group global_macros
    ./src/global_macros/: global_macros.h stm32f1xx_global_macros.h
  group retarget
    ./src/retarget/: retarget.cpp
