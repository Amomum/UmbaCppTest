# Keil uVision project dummy.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: dummy
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT, STM32F10X_MD
  c include: .\src\cmsis;.\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group main
    ./src/Main/: main.cpp example_test.cpp example_test_2.cpp
  group umba_cpp_test
    ./src/umba_cpp_test/: umba_cpp_tests.cpp umba_cpp_tests.h
  group global_macros
    ./src/global_macros/: global_macros.h stm32f1xx_global_macros.h
  group retarget
    ./src/retarget/: retarget.cpp
